

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO SYS_TOP 
  PIN REF_CLK 
    ANTENNAPARTIALMETALAREA 0.018 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.08658 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.734 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.53294 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 0.701188 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 3.45565 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.0235732 LAYER VIA34 ;
  END REF_CLK
  PIN UART_CLK 
    ANTENNAPARTIALMETALAREA 0.165 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.79365 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.616 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.96536 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 1.862 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.14862 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 1.05642 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 5.22712 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.0353598 LAYER VIA45 ;
  END UART_CLK
  PIN RST 
    ANTENNAPARTIALMETALAREA 2.195 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.558 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.678 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.45358 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1755 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 7.17735 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 35.5911 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.617094 LAYER VIA34 ;
  END RST
  PIN RX_IN 
    ANTENNAPARTIALMETALAREA 4.358 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 20.962 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 9.106 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 43.9923 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 3.115 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.1756 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4303 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 52.0331 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 252.678 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.97883 LAYER VIA45 ;
  END RX_IN
  PIN SCAN_CLK 
    ANTENNAPARTIALMETALAREA 0.117 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.56277 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.222 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.26022 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0361 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.796 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.02116 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 3.0628 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 2.04702 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 9.99189 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.0353598 LAYER VIA45 ;
  END SCAN_CLK
  PIN SCAN_RST 
    ANTENNAPARTIALMETALAREA 0.265 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.27465 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.475 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.28715 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.5278 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 13.5645 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 63.88 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 0.420154 LAYER VIA34 ;
  END SCAN_RST
  PIN TEST_MODE 
    ANTENNAPARTIALMETALAREA 3.622 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 17.4218 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1755 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 39.7658 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 184.95 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.411396 LAYER VIA23 ;
  END TEST_MODE
  PIN SE 
    ANTENNAPARTIALMETALAREA 3.661 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 17.6094 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0897 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 80.1761 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 372.106 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.804905 LAYER VIA23 ;
  END SE
  PIN SI[4] 
    ANTENNAPARTIALMETALAREA 6.61 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 31.7941 LAYER METAL2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL2 ; 
    ANTENNAMAXAREACAR 126.635 LAYER METAL2 ;
    ANTENNAMAXSIDEAREACAR 608.463 LAYER METAL2 ;
    ANTENNAMAXCUTCAR 0.677298 LAYER VIA23 ;
  END SI[4]
  PIN SI[3] 
    ANTENNAPARTIALMETALAREA 0.337 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 1.62097 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.878 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.41558 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 13.06 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 63.011 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 458.97 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 2218.51 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 2.70919 LAYER VIA45 ;
  END SI[3]
  PIN SI[2] 
    ANTENNAPARTIALMETALAREA 1.2684 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.09908 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 2.541 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.4146 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 9.429 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 45.5459 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 3.785 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 18.3983 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 162.639 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 796.081 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 4.74109 LAYER VIA56 ;
  END SI[2]
  PIN SI[1] 
    ANTENNAPARTIALMETALAREA 10.08 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 48.4848 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 1.393 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.89273 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 38.136 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 190.002 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA34 ;
  END SI[1]
  PIN SI[0] 
    ANTENNAPARTIALMETALAREA 0.945 LAYER METAL2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.54545 LAYER METAL2 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA23 ;
    ANTENNAPARTIALMETALAREA 0.268 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.48148 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNAPARTIALMETALAREA 30.772 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 148.206 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 989.13 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 4771.5 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 4.74109 LAYER VIA56 ;
  END SI[0]
  PIN SO[4] 
    ANTENNAPARTIALMETALAREA 25.782 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 124.011 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNADIFFAREA 0.6 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 10.085 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 48.7013 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 168.242 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 792.38 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 2.57123 LAYER VIA45 ;
  END SO[4]
  PIN SO[3] 
    ANTENNAPARTIALMETALAREA 3.993 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.3987 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 1.131 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 27.524 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 132.583 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1274 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 222.092 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 1072.21 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.4168 LAYER VIA56 ;
  END SO[3]
  PIN SO[2] 
    ANTENNAPARTIALMETALAREA 5.248 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 25.2429 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 4.837 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 23.4584 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 0.6 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 31.323 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 150.856 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 489.896 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 2367.8 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 3.08547 LAYER VIA56 ;
  END SO[2]
  PIN SO[1] 
    ANTENNAPARTIALMETALAREA 4.824 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 23.2034 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNADIFFAREA 0.6 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 7.156 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 34.6128 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1404 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 75.6011 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 365.447 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 1.54274 LAYER VIA45 ;
  END SO[1]
  PIN SO[0] 
    ANTENNAPARTIALMETALAREA 5.261 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 25.3054 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNADIFFAREA 0.6 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 16.577 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 79.9278 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0702 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 268.97 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 1299.66 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 2.57123 LAYER VIA45 ;
  END SO[0]
  PIN TX_OUT 
    ANTENNAPARTIALMETALAREA 1.125 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.41125 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 0.154 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.93314 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 0.6 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 35.774 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 172.265 LAYER METAL5 ;
  END TX_OUT
  PIN PAR_ERR 
    ANTENNAPARTIALMETALAREA 0.261 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.25541 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNAPARTIALMETALAREA 6.454 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 31.2361 LAYER METAL4 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA45 ;
    ANTENNADIFFAREA 0.456 LAYER METAL5 ; 
    ANTENNAPARTIALMETALAREA 25 LAYER METAL5 ;
    ANTENNAPARTIALMETALSIDEAREA 120.442 LAYER METAL5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.5382 LAYER METAL5 ; 
    ANTENNAMAXAREACAR 66.2205 LAYER METAL5 ;
    ANTENNAMAXSIDEAREACAR 320.451 LAYER METAL5 ;
    ANTENNAMAXCUTCAR 1.11838 LAYER VIA56 ;
  END PAR_ERR
  PIN STOP_ERR 
    ANTENNAPARTIALMETALAREA 27.133 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 130.51 LAYER METAL3 ;
    ANTENNAPARTIALCUTAREA 0.0722 LAYER VIA34 ;
    ANTENNADIFFAREA 0.456 LAYER METAL4 ; 
    ANTENNAPARTIALMETALAREA 10.249 LAYER METAL4 ;
    ANTENNAPARTIALMETALSIDEAREA 49.4901 LAYER METAL4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2054 LAYER METAL4 ; 
    ANTENNAMAXAREACAR 70.0437 LAYER METAL4 ;
    ANTENNAMAXSIDEAREACAR 339.608 LAYER METAL4 ;
    ANTENNAMAXCUTCAR 0.527264 LAYER VIA45 ;
  END STOP_ERR
  PIN test_si6 
    ANTENNAPARTIALMETALAREA 8.158 LAYER METAL3 ;
    ANTENNAPARTIALMETALSIDEAREA 39.24 LAYER METAL3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0533 LAYER METAL3 ; 
    ANTENNAMAXAREACAR 161.644 LAYER METAL3 ;
    ANTENNAMAXSIDEAREACAR 780.468 LAYER METAL3 ;
    ANTENNAMAXCUTCAR 2.03189 LAYER VIA34 ;
  END test_si6
END SYS_TOP

END LIBRARY
